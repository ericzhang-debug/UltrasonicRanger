# Keil uVision project 超声波测距.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: 超声波测距
  c flags: Optimize=8 SizeSpeed=1
  c include: .\LIB;.\USER;.\CORE;.\HARDWARE
  group STARTUP
    ./: STARTUP.A51
  group LIB
    ./LIB/: delay.c GPIO.c
  group USER
    ./USER/: main.c init.c
  group HARDWARE
    ./HARDWARE/: HCSR40.c oled.c
